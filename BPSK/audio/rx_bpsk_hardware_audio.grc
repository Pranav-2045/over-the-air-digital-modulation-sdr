options:
  parameters:
    author: JaganMohan
    category: Custom
    description: DBPSK hardware Audio receiver using USRP B210
    generate_options: qt_gui
    id: rx_bpsk_hardware_audio
    output_language: python
    title: DBPSK Audio Hardware Receiver (USRP B210)
  states: {}

blocks:
- name: Alpha
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: bpsk_const
  id: variable_constellation
  parameters:
    comment: 'BPSK: 2 points on real axis, 1 bit/symbol'
    const_points: '[-1+0j, 1+0j]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: bpsk
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2850000000'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), Alpha, 11*sps*nfilts)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '42'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Real-time 8kHz audio speaker output
    samp_rate: '8000'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: Pack 8 demodulated bits back into bytes (MSB first)
    k: '8'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    comment: Saves recovered 8kHz audio to WAV
    file: rx_recovered_audio.wav
    format: FORMAT_WAV
    samp_rate: '8000'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Decode phase-corrected complex symbols into BPSK indices (0 or 1)
    constellation: bpsk_const
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Costas loop for BPSK phase and carrier tracking
    order: '2'
    w: '0.06'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: Differential decoder for BPSK (modulus 2)
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '45'
    rolloff: Alpha
    samps_per_sym: sps
    type: cc
    w: '0.02'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_audio_deframer
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pycodec2

      SYNDROME_MAP = {
          0b011: 0,
          0b101: 1,
          0b110: 2,
          0b111: 3,
      }

      def decode_nibble(code_byte):
          r0 = (code_byte >> 7) & 1
          r1 = (code_byte >> 6) & 1
          r2 = (code_byte >> 5) & 1
          r3 = (code_byte >> 4) & 1
          p0 = (code_byte >> 3) & 1
          p1 = (code_byte >> 2) & 1
          p2 = (code_byte >> 1) & 1
          
          s0 = r0 ^ r1 ^ r3 ^ p0
          s1 = r0 ^ r2 ^ r3 ^ p1
          s2 = r1 ^ r2 ^ r3 ^ p2
          syndrome = (s2 << 2) | (s1 << 1) | s0

          data = [r0, r1, r2, r3]
          if syndrome in SYNDROME_MAP:
              bit_to_flip = SYNDROME_MAP[syndrome]
              data[bit_to_flip] ^= 1

          nibble = (data[3] << 3) | (data[2] << 2) | (data[1] << 1) | data[0]
          return nibble

      def decode_fec_payload(fec_bytes):
          decoded = bytearray()
          for i in range(0, len(fec_bytes), 2):
              high_nibble = decode_nibble(fec_bytes[i])
              low_nibble = decode_nibble(fec_bytes[i+1])
              orig_byte = (high_nibble << 4) | low_nibble
              decoded.append(orig_byte)
          return bytes(decoded)

      class blk(gr.basic_block):
          """Codec2 3200bps Audio Deframer with Hamming(8,4) FEC Decoding & PLC"""
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Codec2 Audio Deframer',
                  in_sig=[np.uint8],
                  out_sig=[np.float32]
              )
              self.codec2 = pycodec2.Codec2(3200)
              self.samples_per_frame = 160
              self.fec_payload_bytes = 20 # 10 unencoded bytes * 2
              self.frame_len_bytes = 4 + self.fec_payload_bytes # 24 Bytes total
              self.frame_len_bits = self.frame_len_bytes * 8    # 192 Bits total
              self.preamble_bytes = bytes([0xE3, 0x8F, 0x30, 0x7A])
              self.preamble_bits = np.unpackbits(np.frombuffer(self.preamble_bytes, dtype=np.uint8))
              self.preamble_len_bits = 32
              self.max_preamble_errors = 3

              self.bit_buffer = []
              self.out_audio_queue = []
              self.last_seq = -1
              self.frames_received = 0
              self.seq_drops = 0

          def general_work(self, input_items, output_items):
              in_bytes = input_items[0]
              out = output_items[0]
              n_in = len(in_bytes)
              n_out = len(out)

              if n_in > 0:
                  in_bits = np.unpackbits(in_bytes)
                  self.bit_buffer.extend(in_bits)
                  self.consume(0, n_in)

              i = 0
              buf_len = len(self.bit_buffer)
              while i <= buf_len - self.frame_len_bits:
                  window = np.array(self.bit_buffer[i : i + self.preamble_len_bits], dtype=np.uint8)
                  bit_errors = np.sum(window != self.preamble_bits)

                  if bit_errors <= self.max_preamble_errors:
                      frame_bits = np.array(self.bit_buffer[i : i + self.frame_len_bits], dtype=np.uint8)
                      frame_data = np.packbits(frame_bits).tobytes()
                      
                      fec_bytes = frame_data[4:24]
                      raw_payload = decode_fec_payload(fec_bytes) # 10 Bytes: 2B seq + 8B Codec2
                      
                      seq = int.from_bytes(raw_payload[0:2], byteorder='big')
                      
                      if self.last_seq != -1:
                          diff = (seq - self.last_seq) & 0xFFFF
                          if 1 < diff < 50:
                              missing_frames = diff - 1
                              self.seq_drops += missing_frames
                              self.out_audio_queue.extend([0.0] * (missing_frames * self.samples_per_frame))

                      self.last_seq = seq
                      self.frames_received += 1
                      codec2_payload = raw_payload[2:10]
                      
                      try:
                          pcm16_decoded = self.codec2.decode(codec2_payload)
                          float_audio = pcm16_decoded.astype(np.float32) / 32767.0
                          self.out_audio_queue.extend(float_audio)
                      except Exception:
                          self.out_audio_queue.extend([0.0] * self.samples_per_frame)

                      i += self.frame_len_bits
                  else:
                      i += 1

              if i > 0:
                  del self.bit_buffer[:i]

              n_emit = min(len(self.out_audio_queue), n_out)
              if n_emit > 0:
                  out[:n_emit] = np.array(self.out_audio_queue[:n_emit], dtype=np.float32)
                  del self.out_audio_queue[:n_emit]
                  return n_emit

              return 0
    comment: Detects sync preamble, extracts PCM16 audio & feeds to speaker/file
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,1
    gui_hint: 1,0,1,1
    label1: Post-Costas
    label2: Post-Sync
    name: '"BPSK Received Constellation"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark blue
    comment: 2,0,1,2
    grid: 'True'
    gui_hint: 2,0,1,2
    label1: Decoded Audio Waveform
    name: '"Received Audio Time Domain"'
    size: '1024'
    srate: '8000'
    type: float
    ylabel: Audio Amplitude
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: Alpha
    decim: '1'
    gain: '1.0'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_pack_k_bits_bb_0, '0', epy_block_audio_deframer, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '1']
- [epy_block_audio_deframer, '0', audio_sink_0, '0']
- [epy_block_audio_deframer, '0', blocks_wavfile_sink_0, '0']
- [epy_block_audio_deframer, '0', qtgui_time_sink_x_0_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
