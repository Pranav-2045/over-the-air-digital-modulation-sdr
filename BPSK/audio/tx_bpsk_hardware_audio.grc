options:
  parameters:
    author: JaganMohan
    category: Custom
    description: BPSK hardware Audio transmitter using USRP B210
    generate_options: qt_gui
    id: tx_bpsk_hardware_audio
    output_language: python
    title: BPSK Audio Hardware Transmitter (USRP B210)
  states: {}

blocks:
- name: Alpha
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: bpsk_const
  id: variable_constellation
  parameters:
    comment: 'BPSK: 2 points on real axis, 1 bit/symbol'
    const_points: '[-1+0j, 1+0j]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: bpsk
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2850000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '42'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Input 8kHz 16-bit Mono WAV audio file
    file: C:\Users\jagan\Downloads\voice-telephony-8khz.wav
    repeat: 'True'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: Maps bytes to BPSK symbols with differential encoding & RRC shaping
    constellation: bpsk_const
    differential: 'True'
    excess_bw: Alpha
    samples_per_symbol: sps
  states: {}
- name: epy_block_audio_framer
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pycodec2

      def encode_nibble(nibble):
          d0 = (nibble >> 0) & 1
          d1 = (nibble >> 1) & 1
          d2 = (nibble >> 2) & 1
          d3 = (nibble >> 3) & 1
          p0 = d0 ^ d1 ^ d3
          p1 = d0 ^ d2 ^ d3
          p2 = d1 ^ d2 ^ d3
          p3 = d0 ^ d1 ^ d2 ^ d3 ^ p0 ^ p1 ^ p2
          return (d0 << 7) | (d1 << 6) | (d2 << 5) | (d3 << 4) | (p0 << 3) | (p1 << 2) | (p2 << 1) | p3

      def encode_bytes(data_bytes):
          encoded = bytearray()
          for b in data_bytes:
              high_nibble = (b >> 4) & 0x0F
              low_nibble = b & 0x0F
              encoded.append(encode_nibble(high_nibble))
              encoded.append(encode_nibble(low_nibble))
          return bytes(encoded)

      class blk(gr.basic_block):
          """Codec2 3200bps Audio Packetizer with Hamming(8,4) FEC Encoding"""
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Codec2 Audio Framer',
                  in_sig=[np.float32],
                  out_sig=[np.uint8]
              )
              self.codec2 = pycodec2.Codec2(3200)
              self.samples_per_frame = 160  # 20ms at 8kHz
              self.preamble_bytes = bytes([0xE3, 0x8F, 0x30, 0x7A]) # 4 Bytes
              self.seq_num = 0
              self.out_byte_queue = bytearray()
              self.idle_byte = 0x55

          def general_work(self, input_items, output_items):
              in_audio = input_items[0]
              out = output_items[0]
              n_in = len(in_audio)
              n_out = len(out)
              read_idx = 0

              while (n_in - read_idx) >= self.samples_per_frame:
                  chunk = in_audio[read_idx : read_idx + self.samples_per_frame]
                  read_idx += self.samples_per_frame

                  chunk_clipped = np.clip(chunk, -1.0, 1.0)
                  pcm16 = (chunk_clipped * 32767.0).astype(np.int16)
                  encoded_payload = self.codec2.encode(pcm16)
                  seq_bytes = int(self.seq_num & 0xFFFF).to_bytes(2, byteorder='big')
                  self.seq_num = (self.seq_num + 1) & 0xFFFF
                  
                  raw_payload = seq_bytes + bytes(encoded_payload) # 10 Bytes
                  fec_payload = encode_bytes(raw_payload)          # 20 Bytes
                  
                  frame = self.preamble_bytes + fec_payload        # 24 Bytes Total
                  self.out_byte_queue.extend(frame)

              self.consume(0, read_idx)

              n_write = min(len(self.out_byte_queue), n_out)
              if n_write > 0:
                  out[:n_write] = np.frombuffer(self.out_byte_queue[:n_write], dtype=np.uint8)
                  del self.out_byte_queue[:n_write]
                  written = n_write
              else:
                  written = 0

              if written < n_out:
                  out[written:n_out] = self.idle_byte
                  written = n_out

              return written
    comment: Packetizes PCM16 audio with sync preamble & sequence number
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"BPSK TX Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: tx_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_wavfile_source_0, '0', epy_block_audio_framer, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', uhd_usrp_sink_0, '0']
- [epy_block_audio_framer, '0', digital_constellation_modulator_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
