options:
  parameters:
    author: pranav
    category: Custom
    description: DBPSK hardware BER receiver using USRP
    generate_options: qt_gui
    id: rx_bpsk_hardware_ber
    output_language: python
    title: DBPSK Hardware Receiver
  states: {}

blocks:
- name: Alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: bpsk_const
  id: variable_constellation
  parameters:
    comment: 'BPSK: 2 points on real axis, 1 bit/symbol'
    const_points: '[-1+0j, 1+0j]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: bpsk
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2850000000'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), Alpha, 11*sps*nfilts)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '38'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    comment: 0.01 to 0.03
    value: '0.03'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Capture unpacked bits for offline BER calculation
    file: rx_bpsk_bits.bin
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    comment: Discard uncorrected receiver bit decisions
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: 'BPSK: 1 bit per symbol, unpack k=1'
    k: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Decode phase-corrected complex symbols into BPSK indices (0 or 1)
    constellation: bpsk_const
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: bpsk_const
    fmax: '0.05'
    fmin: '-0.05'
    loop_bw: '0.06'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: Differential decoder for BPSK (modulus 2)
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '45'
    rolloff: Alpha
    samps_per_sym: sps
    type: cc
    w: '0.02'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import time
      import os
      import inspect

      class blk(gr.sync_block):
          """DBPSK BER & SNR Calculator & CSV Logger"""
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='BER & SNR Calculator',
                  in_sig=[np.uint8, np.complex64],
                  out_sig=[np.uint8]
              )
              # BPSK preamble: same 11-symbol sequence as TX (values 0 or 1)
              self.preamble = np.array([1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 0], dtype=np.uint8)
              np.random.seed(42)
              # BPSK payload reference: 989 bits (0 or 1)
              self.payload_ref = np.random.randint(0, 2, size=989, dtype=np.uint8)
              
              self.buffer = np.array([], dtype=np.uint8)
              self.total_bits = 0
              self.total_errors = 0
              self.frame_count = 0
              self.printed_debug = False
          
              # Real-time SNR Estimation (Exponential Moving Average)
              self.avg_signal_power = 1.0
              self.avg_noise_power = 0.01
              self.snr_db = 0.0
          
              # Absolute path for CSV file so it writes next to the script
              dir_path = os.path.dirname(os.path.abspath(__file__)) if '__file__' in locals() else '.'
              self.csv_path = os.path.join(dir_path, 'ber_bpsk_log.csv')
              self.csv_file = open(self.csv_path, 'w')
              self.csv_file.write("timestamp,frame,total_bits,total_errors,ber,snr_db\n")
              self.csv_file.flush()

              # Self-contained GUI Label Injection via Stack Frames
              self.top_block = None
              self.ber_label = None
              self.gui_timer = None
          
              for frame_info in inspect.stack():
                  frame = frame_info.frame
                  if 'self' in frame.f_locals:
                      val = frame.f_locals['self']
                      if hasattr(val, 'top_grid_layout'):
                          self.top_block = val
                          break
                          
              if self.top_block:
                  try:
                      from PyQt5.QtWidgets import QLabel
                      from PyQt5.QtCore import QTimer
                      
                      self.ber_label = QLabel("Total Bits: 0 | Errors: 0 | BER: 0.00e+00 | SNR: 0.0 dB")
                      self.ber_label.setStyleSheet("font-size: 16px; font-weight: bold; color: blue; padding: 10px;")
                      self.top_block.top_grid_layout.addWidget(self.ber_label, 0, 0, 1, 2)
                      
                      self.gui_timer = QTimer()
                      self.gui_timer.setInterval(200)
                      self.gui_timer.timeout.connect(self.update_gui)
                      self.gui_timer.start()
                      print(f"[BER] Successfully injected GUI label and timer. CSV logging to: {self.csv_path}")
                  except Exception as e:
                      print(f"[BER] Failed to initialize GUI components: {e}")

          def update_gui(self):
              if self.ber_label:
                  bits = self.total_bits
                  errs = self.total_errors
                  ber = errs / bits if bits > 0 else 0
                  snr = self.snr_db
                  self.ber_label.setText(f"Total Bits: {bits:,} | Errors: {errs:,} | BER: {ber:.2e} | SNR: {snr:.1f} dB")

          def work(self, input_items, output_items):
              in_bits = input_items[0]
              in_iq = input_items[1]
              out = output_items[0]
              
              n_samps = min(len(in_bits), len(in_iq))
              if n_samps == 0:
                  return 0
                  
              # 1. Update Real-Time SNR Estimate from IQ samples
              iq_samps = in_iq[:n_samps]
              reals = iq_samps.real
              sliced = np.where(reals >= 0, 1.0 + 0j, -1.0 + 0j).astype(np.complex64)
              
              noise = iq_samps - sliced
              noise_p = np.mean(np.abs(noise)**2)
              signal_p = np.mean(np.abs(sliced)**2)
              
              alpha_ema = 0.05
              self.avg_signal_power = (1.0 - alpha_ema) * self.avg_signal_power + alpha_ema * signal_p
              self.avg_noise_power = (1.0 - alpha_ema) * self.avg_noise_power + alpha_ema * noise_p
              
              if self.avg_noise_power > 0:
                  self.snr_db = float(10.0 * np.log10(self.avg_signal_power / self.avg_noise_power))
              else:
                  self.snr_db = 0.0

              # 2. Robust Frame Sync & BER Calculation
              data_bits = in_bits[:n_samps]
              data = np.concatenate([self.buffer, data_bits])
              
              idx = 0
              while idx + 1000 <= len(data):
                  # Check 11-bit preamble at current idx
                  window = data[idx : idx + 11]
                  mismatches = int(np.sum(window != self.preamble))
                  
                  if mismatches <= 1:
                      # Preamble matched! Process entire 1000-bit frame
                      rx_pay = data[idx + 11 : idx + 1000]
                      errors = int(np.sum(rx_pay ^ self.payload_ref))
                      self.total_errors += errors
                      self.total_bits += 989
                      self.frame_count += 1
                      
                      if self.frame_count % 50 == 0:
                          ber = self.total_errors / self.total_bits if self.total_bits > 0 else 0
                          print(f"[BER] Frame: {self.frame_count} | Total Bits: {self.total_bits} | Errors: {self.total_errors} | BER: {ber:.2e} | SNR: {self.snr_db:.1f} dB")
                      self.csv_file.write(f"{time.time()},{self.frame_count},{self.total_bits},{self.total_errors},{self.total_errors/self.total_bits:.2e},{self.snr_db:.2f}\n")
                      self.csv_file.flush()
                      
                      # Jump forward by full packet length (1000 bits)
                      idx += 1000
                  else:
                      # Slide window by 1 bit
                      idx += 1
                      
              self.buffer = data[idx:]
                  
              out[:n_samps] = data_bits
              return n_samps

          def stop(self):
              if hasattr(self, 'gui_timer') and self.gui_timer:
                  self.gui_timer.stop()
              if hasattr(self, 'csv_file') and self.csv_file:
                  self.csv_file.close()
              return True
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 1,0,1,1
    gui_hint: 1,0,1,1
    label1: Post-Costas
    label2: Post-Sync
    name: '"BPSK Received Constellation"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark blue
    comment: 2,0,1,2
    ctrlpanel: 'True'
    gui_hint: 2,0,1,2
    label1: RX Decoded Bits
    name: '"Decoded BPSK Bits"'
    size: '128'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: Alpha
    decim: '1'
    gain: '1.0'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '1000000'
    center_freq0: center_freq
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_null_sink_1, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0, '1']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '2']
- [digital_constellation_receiver_cb_0, '4', digital_constellation_decoder_cb_0, '0']
- [digital_constellation_receiver_cb_0, '4', epy_block_1, '1']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', epy_block_1, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '1']
- [epy_block_1, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
