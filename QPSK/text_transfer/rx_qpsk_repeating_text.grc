options:
  parameters:
    author: pranav
    category: Custom
    description: QPSK Repeating Text Receiver with PRBS Descrambler, CRC32 & GUI Display
    generate_options: qt_gui
    id: rx_qpsk_repeating_text
    output_language: python
    title: QPSK Repeating Text Receiver
  states: {}

blocks:
- name: Alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2850000000'
  states: {}
- name: costas_loop_bw
  id: variable_qtgui_range
  parameters:
    comment: may need moving the slider sometimes
    label: Costas Loop BW
    start: '0.001'
    step: '0.001'
    stop: '0.2'
    value: '0.08'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: qpsk_const
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), Alpha, 11*sps*nfilts)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '36'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    label: Timing Loop BW
    start: '0.001'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_const
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: costas_loop_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '128'
    rolloff: Alpha
    samps_per_sym: sps
    type: cc
    w: '0.04'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import struct
      import zlib
      import time
      import os
      import inspect
      from collections import deque

      # Synchronous PRBS whitening keystream matching transmitter
      _rng = np.random.RandomState(42)
      WHITENING_KEY = _rng.randint(0, 256, size=2048, dtype=np.uint8)

      class blk(gr.sync_block):
          """Robust QPSK Text Packet Deframer, Descrambler, CRC32 Verifier & Qt GUI Display"""
          def __init__(self, log_to_file=True):
              gr.sync_block.__init__(
                  self,
                  name='Text Packet Deframer & GUI',
                  in_sig=[np.uint8],
                  out_sig=[]
              )
              self.log_to_file = bool(log_to_file)
              
              # 32-symbol preamble matching transmitter
              self.preamble = np.array([3, 3, 3, 3, 3, 0, 0, 3, 3, 0, 3, 0, 3, 3, 3, 3,
                                        3, 3, 0, 0, 3, 3, 0, 3, 0, 3, 3, 0, 0, 3, 0, 3], dtype=np.uint8)
              
              self.buffer = np.array([], dtype=np.uint8)
              
              # Statistics
              self.total_packets = 0
              self.crc_errors = 0
              self.last_seq = -1
              self.last_text = ""
              self.recent_messages = deque(maxlen=50)
              
              # File Logging
              dir_path = os.path.dirname(os.path.abspath(__file__)) if '__file__' in locals() else '.'
              self.log_path = os.path.join(dir_path, 'rx_text_log.txt')
              self.log_file = None
              if self.log_to_file:
                  try:
                      self.log_file = open(self.log_path, 'a', encoding='utf-8')
                      self.log_file.write(f"\n=== QPSK Text Receiver Started: {time.strftime('%Y-%m-%d %H:%M:%S')} ===\n")
                      self.log_file.flush()
                  except Exception as e:
                      print(f"[RX Deframer] File log init warning: {e}")
                      
              # Qt GUI Widget Injection
              self.top_block = None
              self.status_label = None
              self.text_display = None
              self.gui_timer = None
              
              for frame_info in inspect.stack():
                  frame = frame_info.frame
                  if 'self' in frame.f_locals:
                      val = frame.f_locals['self']
                      if hasattr(val, 'top_grid_layout'):
                          self.top_block = val
                          break
                          
              if self.top_block:
                  try:
                      from PyQt5.QtWidgets import QLabel, QTextEdit, QVBoxLayout, QWidget
                      from PyQt5.QtCore import QTimer
                      
                      self.gui_container = QWidget()
                      layout = QVBoxLayout(self.gui_container)
                      layout.setContentsMargins(4, 4, 4, 4)
                      layout.setSpacing(4)
                      
                      self.status_label = QLabel("Waiting for QPSK signal... [Packets: 0 | CRC Errors: 0]")
                      self.status_label.setStyleSheet(
                          "background-color: #1e1e2e; color: #a6e3a1; font-size: 14px; font-weight: bold; padding: 6px; border-radius: 4px;"
                      )
                      layout.addWidget(self.status_label)
                      
                      self.text_display = QTextEdit()
                      self.text_display.setReadOnly(True)
                      self.text_display.setStyleSheet(
                          "background-color: #181825; color: #cdd6f4; font-family: 'Consolas', monospace; font-size: 12px; border: 1px solid #313244; border-radius: 4px;"
                      )
                      self.text_display.setMinimumHeight(180)
                      layout.addWidget(self.text_display)
                      
                      # Add to GNU Radio QT GUI layout (top row)
                      self.top_block.top_grid_layout.addWidget(self.gui_container, 0, 0, 1, 2)
                      
                      self.gui_timer = QTimer()
                      self.gui_timer.setInterval(150)
                      self.gui_timer.timeout.connect(self.update_gui)
                      self.gui_timer.start()
                      print(f"[RX Deframer] GUI initialized. Log file: {self.log_path}")
                  except Exception as e:
                      print(f"[RX Deframer] GUI setup warning: {e}")

          def symbols_to_bytes(self, syms):
              """Convert array of 2-bit symbols to bytes (4 symbols per byte)"""
              n_bytes = len(syms) // 4
              byte_arr = bytearray(n_bytes)
              for i in range(n_bytes):
                  s0 = int(syms[4*i])
                  s1 = int(syms[4*i + 1])
                  s2 = int(syms[4*i + 2])
                  s3 = int(syms[4*i + 3])
                  byte_arr[i] = (s0 << 6) | (s1 << 4) | (s2 << 2) | s3
              return bytes(byte_arr)

          def update_gui(self):
              if not self.status_label or not self.text_display:
                  return
                  
              total = self.total_packets
              errs = self.crc_errors
              total_attempts = total + errs
              success_pct = (total / total_attempts * 100.0) if total_attempts > 0 else 100.0
              
              status_text = (
                  f"Received Packets: {total:,}  |  CRC Errors: {errs:,}  |  "
                  f"Pass Rate: {success_pct:.1f}%  |  Last Seq: #{self.last_seq}"
              )
              self.status_label.setText(status_text)
              
              lines = []
              while self.recent_messages:
                  lines.append(self.recent_messages.popleft())
                  
              if lines:
                  self.text_display.append("\n".join(lines))
                  sb = self.text_display.verticalScrollBar()
                  sb.setValue(sb.maximum())

          def work(self, input_items, output_items):
              in_syms = input_items[0]
              if len(in_syms) == 0:
                  return 0
                  
              data = np.concatenate([self.buffer, in_syms])
              idx = 0
              n_data = len(data)
              
              # Preamble (32) + Header (28) = 60 symbols minimum
              while idx + 60 <= n_data:
                  window = data[idx : idx + 32]
                  mismatches = int(np.sum(window != self.preamble))
                  
                  if mismatches <= 2:
                      # Descramble 7 header bytes
                      header_raw = bytearray(self.symbols_to_bytes(data[idx + 32 : idx + 60]))
                      for i in range(7):
                          header_raw[i] ^= int(WHITENING_KEY[i % len(WHITENING_KEY)])
                      
                      magic, pkt_type, seq_num, payload_len = struct.unpack('>H B H H', bytes(header_raw))
                      
                      if magic != 0x5AA5 or payload_len > 512:
                          idx += 1
                          continue
                          
                      total_pkt_syms = 32 + 28 + (4 * payload_len) + 16
                      if idx + total_pkt_syms > n_data:
                          break
                          
                      # Descramble payload bytes
                      payload_raw = bytearray(self.symbols_to_bytes(data[idx + 60 : idx + 60 + 4 * payload_len]))
                      for j in range(len(payload_raw)):
                          payload_raw[j] ^= int(WHITENING_KEY[(7 + j) % len(WHITENING_KEY)])
                      
                      # Descramble CRC bytes
                      crc_raw = bytearray(self.symbols_to_bytes(data[idx + 60 + 4 * payload_len : idx + total_pkt_syms]))
                      for k in range(4):
                          crc_raw[k] ^= int(WHITENING_KEY[(7 + payload_len + k) % len(WHITENING_KEY)])
                      
                      rx_crc = struct.unpack('>I', bytes(crc_raw))[0]
                      calc_crc = zlib.crc32(bytes(header_raw) + bytes(payload_raw)) & 0xFFFFFFFF
                      
                      if calc_crc == rx_crc:
                          self.total_packets += 1
                          self.last_seq = seq_num
                          msg = bytes(payload_raw).decode('utf-8', errors='replace')
                          self.last_text = msg
                          
                          log_entry = f"[{time.strftime('%H:%M:%S')}] [Pkt #{seq_num:05d}] {msg}"
                          self.recent_messages.append(log_entry)
                          
                          if self.total_packets % 25 == 0 or self.total_packets <= 5:
                              print(f"[RX QPSK] Received Pkt #{seq_num:05d}: {msg} (CRC OK)")
                              
                          if self.log_file:
                              try:
                                  self.log_file.write(f"{log_entry}\n")
                                  if self.total_packets % 10 == 0:
                                      self.log_file.flush()
                              except Exception:
                                  pass
                                  
                          idx += total_pkt_syms
                      else:
                          self.crc_errors += 1
                          if self.crc_errors % 25 == 0 or self.crc_errors <= 5:
                              print(f"[RX QPSK WARNING] CRC Error on Pkt #{seq_num} (calc={hex(calc_crc)}, rx={hex(rx_crc)})")
                          idx += total_pkt_syms
                  else:
                      idx += 1
                      
              if idx < n_data:
                  self.buffer = data[idx:]
              else:
                  self.buffer = np.array([], dtype=np.uint8)
                  
              if len(self.buffer) > 10000:
                  self.buffer = self.buffer[-2000:]
                  
              return len(in_syms)

          def stop(self):
              if hasattr(self, 'gui_timer') and self.gui_timer:
                  self.gui_timer.stop()
              if hasattr(self, 'log_file') and self.log_file:
                  try:
                      self.log_file.flush()
                      self.log_file.close()
                  except Exception:
                      pass
              return True
    comment: QPSK Text Deframer & Qt GUI Display
    log_to_file: 'True'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      ======================================================================
                 QPSK RECEIVER SYNCHRONIZATION TUNING GUIDE
      ======================================================================

      1. COSTAS LOOP BANDWIDTH (costas_loop_bw):
         - What it does:
           Tracks carrier phase and eliminates fine carrier frequency offset
           between the transmitter and receiver oscillators.
         - How to adjust:
           * HIGHER (0.06 - 0.10):
             Widens the frequency acquisition (pull-in) range. Crucial when
             operating at high RF frequencies (e.g., 2.85 GHz) where USRP TCXO
             crystal offsets are 5 kHz - 12 kHz.
             * Symptom if too low (< 0.04): Constellation fails to lock and
               spins in 8 clusters (dynamic phase slips across 45-deg boundaries).
             * Symptom if too high (> 0.15): Constellation clusters smear/blur
               due to excessive phase noise tracking.
           * Recommendation:
             Keep default at 0.07 - 0.08 for instant hardware capture.

      ----------------------------------------------------------------------

      2. TIMING LOOP BANDWIDTH (timing_loop_bw):
         - What it does:
           Symbol clock synchronization (Gardner TED in Symbol Sync block).
           Finds the exact optimal time instant to sample each symbol at 1 SPS.
         - How to adjust:
           * HIGHER (0.02 - 0.05):
             Faster clock lock; tracks sudden sample-rate clock drift.
           * LOWER (0.005 - 0.015):
             Minimizes timing jitter and inter-symbol interference (ISI).
           * Recommendation:
             Keep at 0.01. Only increase if constellation points spread radially
             along symbol transition trajectories.

      ----------------------------------------------------------------------

      3. FLL BAND-EDGE BANDWIDTH (w in digital_fll_band_edge_cc):
         - What it does:
           Performs coarse carrier frequency offset estimation by balancing
           energy at the upper and lower Nyquist band edges (+/- (1+Alpha)*Rs/2).
         - How to adjust:
           * Set to 0.03 - 0.05 to rapidly pull in large initial crystal offsets
             before the signal reaches the Costas loop.
           * If set too low (0.01), convergence is sluggish, forcing the Costas
             loop to do all the heavy lifting.
      ======================================================================
    note: receiver tuning guide
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: uhd.tune_request(center_freq, samp_rate/2)
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_map_bb_0, '0', epy_block_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
